Properties of the parts of a building model (IFC2X3)

# File
Description: Fühlerschutz für Hygrostat HI-1 / HI1F / HI2, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H530975, Fühlerschutz für Hygrostat HI-1 / HI1F / HI2
In: Raum
Description: Fühlerschutz für Hygrostat HI-1 / HI1F / HI2. Feinmaschiges Drahtgeflecht für Einsatz bei hohen Luftgeschwindigkeiten über 8 m/s.; Classification: EC002584 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H530975; ModelLabel: FS-HI; GlobalTradeItemNumber: 4050528044990; ProductURL: https://alre.de/produkt_H530975
Pset_Specification - NominalLength: 0.17 m; NominalWidth: 0.017 m; NominalDepth: 0.017 m; NetWeight: 0.009
Pset_ALRE_ETIM_Properties - ETIM-Klasse: EC002584; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H530975.pdf
